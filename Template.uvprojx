# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::D:\WORK\embedded development\Keil_AC5\ARM\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\usart;.\APP\DIGITAL_TUBES;.\APP\kalman;.\APP\key;.\APP\motor;.\APP\move;.\APP\OLED;.\APP\pid;.\APP\plan;.\APP\sensor;.\APP\steering;.\APP\trace;.\APP\VOFA;.\APP\MPU9250;.\APP\MPU9250_Driver;.\APP\yysb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group APP
    ./APP/led/: led.c
    ./APP/usart/: usart.c
    ./APP/DIGITAL_TUBES/: tubes.c
    ./APP/key/: key.c
    ./APP/motor/: motor.c
    ./APP/move/: move.c
    ./APP/OLED/: oled.c
    ./APP/pid/: pid.c
    ./APP/plan/: plan.c
    ./APP/steering/: steering.c
    ./APP/trace/: trace.c
    ./APP/VOFA/: VOFA.c
    ./APP/sensor/: B_GREY_driver.c F_GREY_driver.c L_GREY_driver.c R_GREY_driver.c sensor.c
    ./APP/yysb/: yysb.c
  group MPU9250
    ./APP/MPU9250/: imu.c
    ./APP/MPU9250_Driver/: imu_driver.c
  group Public
    ./Public/: system.c SysTick.c
